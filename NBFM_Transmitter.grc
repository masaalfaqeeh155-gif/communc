options:
  parameters:
    author: ASUS
    generate_options: qt_gui
    id: Part2_NBFM_Transmitter
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_gain
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: max_dev
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: max_dev
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4000'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: quad_rate
    fc: '0'
    fftsize: '2048'
    name: NBFM Spectrum
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: NBFM Signal Sent to Pluto
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: Microphone Audio
    size: '1024'
    srate: audio_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '24'
    fbw: '0.4'
    interp: '125'
    type: ccf
  states: {}

connections:
- [analog_nbfm_tx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_nbfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
